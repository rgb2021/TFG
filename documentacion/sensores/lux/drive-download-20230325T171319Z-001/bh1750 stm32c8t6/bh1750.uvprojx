# Keil uVision project bh1750.uvprojx, settings and files
target BH1750 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bh1750
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\HARDWARE\bh1750;.\HARDWARE\LED;.\HARDWARE\TIMER;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\iic;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\pwm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM_LIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/bh1750/: bh1750.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/TIMER/: timer.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/iic/: myiic.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
